# KOMPAS-3D part (ZARD 125.080.40.P.m3d)

Model tree:
1. Булева операция:1
2. Булева операция:2
